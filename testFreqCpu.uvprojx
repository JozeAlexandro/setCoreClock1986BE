# Keil uVision project testFreqCpu.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: testFreqCpu +hex
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\coreClock1986BE\h;.\coreClock1986BE\src;..\testFreqCpu
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: testFreqCpu.c
    ./coreClock1986BE/src/: coreClock1986BE.c
software components: Device:Startup 2.0.3, Drivers:RST_CLK 2.0.3
